options:
  parameters:
    generate_options: qt_gui
    id: noaa_weather
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_center
  id: variable
  parameters:
    value: 162.55e6
  states: {state: disabled}
- name: f_center
  id: variable_qtgui_range
  parameters:
    start: 500e3
    step: 0.2e6
    stop: 163e6
    value: 162.55e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '32000'
    max_dev: 5e3
    quad_rate: '64000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '32000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '16'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    label1: Spectral
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: f_center
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
