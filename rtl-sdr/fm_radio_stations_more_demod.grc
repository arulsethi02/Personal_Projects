options:
  parameters:
    author: aruls
    generate_options: qt_gui
    id: fm_radio_stations_more_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_center
  id: variable_qtgui_range
  parameters:
    start: 88.1e6
    step: 0.2e6
    stop: 107.9e6
    value: 105.9e6
  states: {}
- name: f_cutoff
  id: variable_qtgui_range
  parameters:
    start: 50e3
    step: 50e3
    stop: 350e3
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 192e3 /(2*math.pi*75e3)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*f_cutoff
    fc: '0'
    fftsize: '1024'
    label1: Spectral
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: f_center
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
