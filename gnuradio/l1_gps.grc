options:
  parameters:
    author: aruls
    generate_options: qt_gui
    id: l1_gps
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_l1
  id: variable
  parameters:
    value: 1.57242e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 3e6
    fc: '0'
    fftsize: '1024'
    label1: Spectral
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: 'True'
    center_freq: f_l1
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
